# Keil uVision project adc.uvproj, settings and files
target ADC_LPC21xx (5050169::V5.05 update 2 (build 169)::.\ARMCC_505u2)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: adc +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x2000 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group StartUp Codes
    ./: Startup.s serial.c
  group Sources
    ./: main.c lcd.c adc.c
  group Documents
    ./: Abstract.txt
