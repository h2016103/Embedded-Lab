# Keil uVision project I2CLPC2148.uvproj, settings and files
target I2CLPC2148 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: I2CLPC2148 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1
  memory RVCT4: ROM 0x2000 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source
    ./: Startup.s I2C.c main.c timer.c uart.c extn_int.c lcd.c
  group Header
    ./: I2C.h timer.h type.h uart.h
